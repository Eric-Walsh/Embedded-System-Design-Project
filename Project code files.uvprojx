# Keil uVision project Project code files.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project code files
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./code files/: ADC_Functions.c ADC_Functions.h Calculations.c Calculations.h DAC_Functions.c DAC_Functions.h debug_signals.c gpio_defs.h Interface_functions.c Interface_Functions.h LCD_Functions.c LCD_Functions.h lcd_lib_4bit_20b.c LEDs.h LEDs.c main.c Pit_Functions.c PIT_Functions.h Recordings.c Recordings.h StartUp_Functions.c StartUp_Functions.h switches.c switches.h
software components: CMSIS:CORE 5.3.0, Device:Startup 2.5.0
